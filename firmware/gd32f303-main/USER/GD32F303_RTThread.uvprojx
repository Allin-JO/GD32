# Keil uVision project GD32F303_RTThread.uvprojx, settings and files
target GD32F303_RTThread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M4") CLOCK(8000000) ELITTLE
  output: GD32F303_RTThread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\BOARD;..\APP;..\rt-thread\include;..\GD32F30x_FWLib\CMSIS\Include;..\GD32F30x_FWLib\Include;..\GD32F30x_FWLib\CMSIS\Source;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWARE\ADC;..\HAREWARE\KEY;..\HAREWARE\TIM;..\HAREWARE\OLED;..\HAREWARE\LED;..\HAREWARE\USART_X;..\HAREWARE\I2C;..\HAREWARE\ICM20948;..\HAREWARE\Encoder;..\HAREWARE\MOTOR;..\HAREWARE\CMD;..\BALANCE\CONCTRL;..\BALANCE\SHOW
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HAREWARE
    ../HAREWARE/KEY/: KEY.c
    ../HAREWARE/OLED/: oled.c
    ../HAREWARE/LED/: LED.c
    ../HAREWARE/USART_X/: usart_x.c
    ../HAREWARE/I2C/: I2C.c
    ../HAREWARE/ICM20948/: ICM20948.c
    ../HAREWARE/Encoder/: Encoder.c
    ../HAREWARE/TIM/: TIM.c
    ../HAREWARE/MOTOR/: motor.c
    ../HAREWARE/ADC/: adc.c
    ../HAREWARE/CMD/: cmd.c
  group BALANCE
    ../BALANCE/CONCTRL/: conctrl.c
    ../BALANCE/SHOW/: show.c
  group BOARD
    ../BOARD/: board.c
  group APP
    ../APP/: app.c app_motion.c app_display.c
  group RT-THREAD-KERNEL
    ../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group RT-THREAD-PORT
    ../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group GD32-CMSIS
    ../GD32F30x_FWLib/CMSIS/Source/: startup_gd32f30x_hd.s system_gd32f30x.c
  group GD32-FWLIB
    ../GD32F30x_FWLib/Source/: gd32f30x_adc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
