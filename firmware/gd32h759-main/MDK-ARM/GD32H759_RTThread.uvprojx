# Keil uVision project GD32H759_RTThread.uvprojx, settings and files
target GD32H759_RTThread (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.0.1.1
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GD32H759_RTThread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32H7XX
  c include: ..\USER;..\BOARD;..\APP;..\rt-thread\include;..\GD32H7xx_Firmware_Library\CMSIS\GD\GD32H7xx\Include;..\GD32H7xx_Firmware_Library\GD32H7xx_standard_peripheral\Include;..\SYSTEM\delay;..\SYSTEM\sys;..\HAREWARE\ADC;..\HAREWARE\CMD;..\HAREWARE\Encoder;..\HAREWARE\KEY;..\HAREWARE\LED;..\HAREWARE\MOTOR;..\HAREWARE\OLED;..\HAREWARE\TIM;..\HAREWARE\USART_X;..\BALANCE\CONCTRL;..\BALANCE\SHOW
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group USER
    ../USER/: main.c
  group BOARD
    ../BOARD/: board.c board_h759.c
  group APP
    ../APP/: app.c app_motion.c app_display.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HAREWARE/ADC/: adc.c
    ../HAREWARE/CMD/: cmd.c
    ../HAREWARE/Encoder/: Encoder.c
    ../HAREWARE/KEY/: KEY.c
    ../HAREWARE/LED/: LED.c
    ../HAREWARE/MOTOR/: motor.c
    ../HAREWARE/OLED/: oled.c
    ../HAREWARE/TIM/: TIM.c
    ../HAREWARE/USART_X/: usart_x.c
  group BALANCE
    ../BALANCE/CONCTRL/: conctrl.c
    ../BALANCE/SHOW/: show.c
  group RT-THREAD-KERNEL
    ../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group RT-THREAD-PORT
    ../rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpuport.c
  group GD32-CMSIS
    ../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
    ../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group GD32-FWLIB
    ../GD32H7xx_Firmware_Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_gpio.c gd32h7xx_misc.c gd32h7xx_rcu.c gd32h7xx_timer.c gd32h7xx_usart.c
software components: CMSIS:CORE 5.2.0
